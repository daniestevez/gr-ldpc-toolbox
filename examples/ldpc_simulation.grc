options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: ldpc_simulation
    output_language: python
    title: LDPC simulation
  states: {}

blocks:
- name: alist
  id: variable
  parameters:
    value: '''../python/ldpc_toolbox/ar4ja_1_2_1024.alist'''
  states: {}
- name: ebn0
  id: variable_qtgui_entry
  parameters:
    label: Eb/N0 (dB)
    type: real
    value: '2.2'
  states: {}
- name: esn0
  id: variable
  parameters:
    value: rate * 10**(ebn0/10)
  states: {}
- name: k
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: n
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: noise_sigma
  id: variable
  parameters:
    value: np.sqrt(0.5 / esn0)
  states: {}
- name: puncturing
  id: variable
  parameters:
    comment: |-
      Puncturing pattern for
      CCSDS r=1/2 LDPC
    value: '''1,1,1,1,0'''
  states: {}
- name: rate
  id: variable
  parameters:
    value: k / n
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_sigma
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert to LLR
    const: '-2.0 / noise_sigma**2'
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: byte
  states: {}
- name: blocks_probe_rate_1
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: k
    type: byte
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: n
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: n
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: k
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ldpc_toolbox_ldpc_decoder_0
  id: ldpc_toolbox_ldpc_decoder
  parameters:
    alist: alist
    implementation: '''Phif64'''
    k: k
    max_iterations: '200'
    n: n
    puncturing: puncturing
  states: {}
- name: ldpc_toolbox_ldpc_encoder_0
  id: ldpc_toolbox_ldpc_encoder
  parameters:
    alist: alist
    k: k
    n: n
    puncturing: puncturing
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 0,0,1,1
    name: Received symbols histogram
    size: '100000'
    type: float
    xmax: '3'
    xmin: '-3'
  states: {}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: 0,1,1,1
    name: LLRs histogram
    size: '100000'
    type: float
    xmax: '20'
    xmin: '-20'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    marker1: '0'
    name: Decoded bits
    size: k
    srate: '1'
    style1: '0'
    type: float
    ylabel: Value
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    marker1: '0'
    name: Received symbols
    size: n
    srate: '1'
    style1: '0'
    type: float
    ylabel: Value
    ymax: '3'
    ymin: '-3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: encoded_symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: encoded_symbols
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_uniform_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_probe_rate_1, rate, blocks_message_debug_0_0, print]
- [blocks_stream_to_vector_0, '0', ldpc_toolbox_ldpc_encoder_0, '0']
- [blocks_stream_to_vector_1, '0', ldpc_toolbox_ldpc_decoder_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_probe_rate_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_probe_rate_0, '0']
- [ldpc_toolbox_ldpc_decoder_0, '0', blocks_vector_to_stream_0_0, '0']
- [ldpc_toolbox_ldpc_encoder_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
